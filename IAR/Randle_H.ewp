# IAR project Randle_H.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\Libraries\Devices\inc; ..\Libraries\Devices\src; ..\Libraries\Drivers\inc; ..\Libraries\Drivers\src; ..\Libraries\Startup\DeviceSupport; ..\Libraries\Startup\CoreSupport; ..\Libraries\Tools\inc; ..\Libraries\Tools\src; ..\Libraries\Tools; ..\Users\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Randle_H.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Devices/inc
    ../Libraries/Devices/inc/: MOTOR.h MT9V032.h NRF24L01.h ST7735.h TD8320MG.h
  group Devices/src
    ../Libraries/Devices/src/: MOTOR.c MT9V032.c NRF24L01.c ST7735.c TD8320MG.c
  group Doc
    ../Libraries/Doc/: ASCII表.txt PORT引脚.txt
  group Drivers/inc
    ../Libraries/Drivers/inc/: c_smartcar.h cmdesk_c_smartcar.h port.h spi.h systick.h uart.h
  group Drivers/src
    ../Libraries/Drivers/src/: c_smartcar.c cmdesk_c_smartcar.c port.c spi.c systick.c uart.c
  group Startup
    ../Libraries/Startup/CoreSupport/: core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../Libraries/Startup/DeviceSupport/: MK66F18.h system_MK66.c
    ../Libraries/Startup/DeviceSupport/IAR-ARM/: startup_MK66F18.s
  group Tools/inc
    ../Libraries/Tools/: tft_font.h
  group Tools/inc/image
    ../Libraries/Tools/inc/: image.h img_bin.h img_canny.h img_filter.h img_gussian.h img_stat.h
  group Tools/inc/math
    ../Libraries/Tools/inc/: fourier.h mathematics.h
  group Tools/src
    ../Libraries/Tools/src/: fourier.c image.c mathematics.c
  group Users/inc
    ../Users/inc/: common.h headfiles.h information.h interrupt.h MK60_port.h nxp_contest.h
  group Users/src
    ../Users/src/: information.c interrupt.c main.cpp nxp_contest.c
